# IAR project snn_test_FSBL.ewp, settings and files
configuration snn_test_FSBL (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 0
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx
  ICCARM.CCIncludePath2: ../../FSBL/X-CUBE-AI/App; ../../FSBL/X-CUBE-AI; ../../FSBL/Core/Inc; ../../Middlewares/ST/AI/Inc; ../../Drivers/STM32N6xx_HAL_Driver//Inc; ../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: snn_test_FSBL.bin
  ILINK.IlinkOutputFile: snn_test_FSBL.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx_fsbl.s
  group Application/User/FSBL/Lib
    ../../Middlewares/ST/AI/Lib/: NetworkRuntime1000_CM55_IAR.a
  group Application/User/FSBL/X-CUBE-AI/App
    ../../FSBL/X-CUBE-AI/App/: network.c network_data.c network_data_params.c aiSystemPerformance.c aiTestHelper.c aiTestUtility.c ai_device_adaptor.c lc_print.c syscalls.c app_x-cube-ai.c
  group Application/User/FSBL/Core
    ../../FSBL/Core/Src/: main.c stm32n6xx_it.c stm32n6xx_hal_msp.c
  group Doc
    ../../FSBL/X-CUBE-AI/App/: network_generate_report.txt
  group Drivers/STM32N6xx_HAL_Driver
    ../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_cortex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c
  group Drivers/CMSIS
    ../../FSBL/Core/Src/: system_stm32n6xx_fsbl.c
